# Keil uVision project gpio.uvproj, settings and files
target GPIO (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: gpio +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD_VL
  c include: .\USER;..\..\stm32vldiscovery_package\Libraries\CMSIS\CM3\CoreSupport;..\..\stm32vldiscovery_package\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\stm32vldiscovery_package\Libraries\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ./USER/: main.c stm32f10x_it.c
  group CMSIS
    ../../stm32vldiscovery_package/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../stm32vldiscovery_package/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group STD_PERIPH
    ../../stm32vldiscovery_package/Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_tim.c misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_exti.c
  group Startup
    ../../stm32vldiscovery_package/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md_vl.s
